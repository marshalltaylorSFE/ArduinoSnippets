#include <StandardCplusplus.h>
//#include <system_configuration.h>
//#include <unwind-cxx.h>
//#include <utility.h>

#include "stdint.h"
#include "MidiFile.h"
#include "Binasc.h"

#include <string.h>
#include <iostream>
#include <iomanip>
#include "ardfstream.h"
#include <sstream>
#include <stdlib.h>


const uint8_t midiFileLUT [217] = { 0x4D, 0x54, 0x68, 0x64, 0x00, 0x00, 0x00, 0x06, 0x00, 0x01, 0x00, 0x02, 0x00, 0xC0, 0x4D, 0x54, 0x72, 0x6B, 0x00, 0x00, 0x00, 0x65, 0x00, 0xFF, 0x58, 0x04, 0x04, 0x02, 0x18, 0x08, 0x00, 0xFF, 0x51, 0x03, 0x07, 0xA1, 0x20, 0x00, 0xFF, 0x03, 0x05, 0x6D, 0x61, 0x6A, 0x6F, 0x72, 0x00, 0x90, 0x30, 0x64, 0x81, 0x3F, 0x80, 0x30, 0x30, 0x01, 0x90, 0x3C, 0x64, 0x81, 0x3F, 0x80, 0x3C, 0x30, 0x01, 0x90, 0x30, 0x64, 0x81, 0x3F, 0x80, 0x30, 0x30, 0x01, 0x90, 0x3C, 0x64, 0x81, 0x3F, 0x80, 0x3C, 0x30, 0x01, 0x90, 0x40, 0x64, 0x81, 0x3F, 0x80, 0x40, 0x30, 0x01, 0x90, 0x3C, 0x64, 0x81, 0x3F, 0x80, 0x3C, 0x30, 0x01, 0x90, 0x30, 0x64, 0x81, 0x3F, 0x80, 0x30, 0x30, 0x01, 0x90, 0x3C, 0x64, 0x81, 0x3F, 0x80, 0x3C, 0x30, 0xB0, 0x01, 0xFF, 0x2F, 0x00, 0x4D, 0x54, 0x72, 0x6B, 0x00, 0x00, 0x00, 0x56, 0x00, 0xFF, 0x03, 0x05, 0x6D, 0x69, 0x6E, 0x6F, 0x72, 0x00, 0x90, 0x48, 0x64, 0x81, 0x3E, 0x80, 0x48, 0x30, 0x01, 0x90, 0x54, 0x64, 0x81, 0x3F, 0x80, 0x54, 0x30, 0x01, 0x90, 0x48, 0x64, 0x81, 0x3F, 0x80, 0x48, 0x30, 0x01, 0x90, 0x54, 0x64, 0x81, 0x3F, 0x80, 0x54, 0x30, 0x01, 0x90, 0x57, 0x64, 0x81, 0x3F, 0x80, 0x57, 0x30, 0x01, 0x90, 0x54, 0x64, 0x81, 0x3F, 0x80, 0x54, 0x30, 0x01, 0x90, 0x48, 0x64, 0x81, 0x3F, 0x80, 0x48, 0x30, 0x01, 0x90, 0x54, 0x64, 0x81, 0x3F, 0x80, 0x54, 0x30, 0xB0, 0x02, 0xFF, 0x2F, 0x00 };

void setup()
{

   //Options options;
   //options.process(argc, argv);
   uint8_t * fileAddress;
   fileAddress = (uint8_t *)0x123;
   MidiFile midifile(fileAddress);
   //if (options.getArgCount() > 0) {
   //   midifile.read(options.getArg(1));
   //} else {
   //   midifile.read(cin);
   //}

   int tracks = midifile.getTrackCount();
   //cout << "TPQ: " << midifile.getTicksPerQuarterNote() << endl;
   if (tracks > 1)
   {
      //cout << "TRACKS: " << tracks << endl;
   }
   for (int track=0; track < tracks; track++)
   {
      if (tracks > 1)
	  {
      //   cout << "\nTrack " << track << endl;
      }
      for (int event=0; event < midifile[track].size(); event++)
	  {
      //   cout << dec << midifile[track][event].tick;
      //   cout << '\t' << hex;
      //   for (int i=0; i<midifile[track][event].size(); i++) {
      //      cout << (int)midifile[track][event][i] << ' ';
      //   }
      //   cout << endl;
      //
	  }
   }


}

void loop()
{
}
